# IAR project bao-baremetal-guest.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCDefines: MEM_NON_UNIFIED
  ICCRH850.CCIncludePath2: src; src/core/inc; src/arch/rh850/inc; src/platform/rh850-u2a16/inc; src/drivers/renesas_rlin3/inc; src/drivers/rh850-u2a16_ostm/inc
  IASMRH850.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: bao-baremetal-guest.hex
  ILINK.IlinkOutputFile: bao-baremetal-guest.out
  ILINK.IlinkIcfFile: src/ld/rh850-u2a16.icf
  ILINK.IlinkStackSize: 0
  ILINK.IlinkHeapSize: 0
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG; MEM_NON_UNIFIED
  ILINK.IlinkOutputFile: baremetal.out
  group app
    src/: main.c
  group arch
    src/arch/rh850/: cycle_counter.c exceptions.S exceptions_iar.S init.c intc.c irq.c start.S start_iar.S
  group core
    src/core/: irq.c retarget.c retarget_iar.c virtio_console.c
  group drivers
    src/drivers/renesas_rlin3/: renesas_rlin3.c
  group ld
    src/ld/: rh850-u2a16.icf
  group platform
    src/platform/rh850-u2a16/inc/: plat.h
    src/platform/rh850-u2a16/: u2a16.c
